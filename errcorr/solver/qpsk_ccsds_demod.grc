<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>qpsk_ccsds_demod</value></param>
<param><key>author</key><value>Cromulence</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>QPSK and CSSDS FEC</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>QPSK CCSDS RX</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>arity</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>variable_constellation</key>
<param><key>id</key><value>constel</value></param>
<param><key>const_points</key><value>[(1+1j),(-1-1j),(1-1j),(-1+1j)]</value></param>
<param><key>type</key><value>calcdist</value></param>
<param><key>dims</key><value>1</value></param>
<param><key>rot_sym</key><value>4</value></param>
<param><key>soft_dec_lut</key><value>'auto'</value></param>
<param><key>precision</key><value>8</value></param>
<param><key>sym_map</key><value>digital.psk_4()[1]</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>dec_cc</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>k</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>frame_size*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>polys</value></param>
<param><key>rate</key><value>rate</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable_ccsds_encoder_def</key>
<param><key>id</key><value>enc_ccsds</value></param>
<param><key>framebits</key><value>frame_size*8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_STREAMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>k</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>polys</value></param>
<param><key>value</key><value>[109, 79]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rate</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rrc_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>100000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/out/out.bin</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_1</value></param>
<param><key>file</key><value>/out/intermediate.bin</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_pack_k_bits_bb</key>
<param><key>id</key><value>blocks_pack_k_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>digital_constellation_soft_decoder_cf</key>
<param><key>id</key><value>digital_constellation_soft_decoder_cf_0_0</value></param>
<param><key>constellation</key><value>constel</value></param>
</block>
<block>
<key>digital_pfb_clock_sync_xxx</key>
<param><key>id</key><value>digital_pfb_clock_sync_xxx_0_0</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>loop_bw</key><value>6.28/100.0</value></param>
<param><key>max_dev</key><value>1.5</value></param>
<param><key>osps</key><value>1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>taps</key><value>rrc_taps</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fec_extended_decoder</key>
<param><key>id</key><value>fec_extended_decoder_0</value></param>
<param><key>decoder_list</key><value>dec_cc</value></param>
<param><key>puncpat</key><value>puncpat</value></param>
<param><key>threadtype</key><value>capillary</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_size</value></param>
<param><key>label</key><value>Frame Size</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_cmath</value></param>
<param><key>import</key><value>import cmath</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_math</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_auto</value></param>
<param><key>note</key><value>auto-build LUT</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_py</value></param>
<param><key>note</key><value>Python-generated LUT</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>puncpat</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>'11'</value></param>
</block>
<connection><source_block_id>blocks_file_source_1</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pack_k_bits_bb_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>digital_pfb_clock_sync_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_constellation_soft_decoder_cf_0_0</source_block_id><sink_block_id>fec_extended_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_pfb_clock_sync_xxx_0_0</source_block_id><sink_block_id>digital_constellation_soft_decoder_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_decoder_0</source_block_id><sink_block_id>blocks_pack_k_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
